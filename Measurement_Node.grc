options:
  parameters:
    author: Frank von Schoettler
    generate_options: qt_gui
    id: Measurement_Campaign_Mesh_SEW
    output_language: python
    realtime_scheduling: '1'
    title: Poisson_Transceiver
  states: {}

blocks:
- name: Lambda
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '100'
    value: '2'
  states: {}
- name: N_Zc
  id: variable
  parameters:
    value: '61 '
  states: {}
- name: Node_ID
  id: variable
  parameters:
    value: '1'
  states: {}
- name: Resampled_factor
  id: variable
  parameters:
    value: '2'
  states: {}
- name: Tau
  id: variable_qtgui_range
  parameters:
    start: '0.001'
    step: '0.01'
    stop: '2'
    value: '0.005'
  states: {}
- name: center_freq_mhz
  id: variable
  parameters:
    value: '3750'
  states: {}
- name: rx_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1.9e6
  states: {}
- name: tx_gain
  id: variable
  parameters:
    value: '1'
  states: {}
- name: vector_size
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: zc_seq0_resampled_2times
  id: variable
  parameters:
    value: (1.00000+0.00000j, 0.99925-0.16678j, 0.99470-0.10282j, 0.98144-0.06326j, 0.95264-0.30411j, 0.90009-0.56507j, 0.81503-0.57942j, 0.68881-0.59433j, 0.51479-0.85731j, 0.29159-1.08881j, 0.02575-0.99967j, -0.26675-0.82934j, -0.55824-0.82968j, -0.80799-0.72661j, -0.96703-0.25467j, -0.98931+0.28078j, -0.84378+0.53670j, -0.52669+0.70761j, -0.07718+0.99702j, 0.41341+1.05804j, 0.81503+0.57942j, 0.99638-0.08719j, 0.87029-0.49255j, 0.43754-0.74336j, -0.17928-0.98380j, -0.74515-0.83268j, -0.99867-0.05148j, -0.78874+0.78042j, -0.17928+0.98380j, 0.54328+0.65869j, 0.97886+0.20455j, 0.82787-0.38133j, 0.12840-0.99172j, -0.67682-0.94111j, -0.99867+0.05148j, -0.55969+1.03381j, 0.32854+0.94449j, 0.95160+0.04060j, 0.75113-0.66015j, -0.15055-0.74164j, -0.93572-0.35275j, -0.78117+0.38473j, 0.22969+0.97326j, 1.00565+0.50838j, 0.60021-0.79984j, -0.54466-1.18591j, -0.98809+0.15389j, -0.13415+1.34066j, 0.87029+0.49255j, 0.64220-1.09283j, -0.46998-0.88268j, -0.84954+0.69997j, 0.02575+0.99967j, 0.80809-0.35357j, 0.32854-0.94449j, -0.62432+0.13048j, -0.55824+0.82968j, 0.38309-0.02635j, 0.67927-0.73389j, -0.12804-0.00000j, -0.71615+0.69794j, -0.12804-0.00000j, 0.67927-0.73389j, 0.38309-0.02635j, -0.55824+0.82968j, -0.62432+0.13048j, 0.32854-0.94449j, 0.80809-0.35357j, 0.02575+0.99967j, -0.84954+0.69997j, -0.46998-0.88268j, 0.64220-1.09283j, 0.87029+0.49255j, -0.13415+1.34066j, -0.98809+0.15389j, -0.54466-1.18591j, 0.60021-0.79984j, 1.00565+0.50838j, 0.22969+0.97326j, -0.78117+0.38473j, -0.93572-0.35275j, -0.15055-0.74164j, 0.75113-0.66015j, 0.95160+0.04060j, 0.32854+0.94449j, -0.55969+1.03381j, -0.99867+0.05148j, -0.67682-0.94111j, 0.12840-0.99172j, 0.82787-0.38133j, 0.97886+0.20455j, 0.54328+0.65869j, -0.17928+0.98380j, -0.78874+0.78042j, -0.99867-0.05148j, -0.74515-0.83268j, -0.17928-0.98380j, 0.43754-0.74336j, 0.87029-0.49255j, 0.99638-0.08719j, 0.81503+0.57942j, 0.41341+1.05804j, -0.07718+0.99702j, -0.52669+0.70761j, -0.84378+0.53670j, -0.98931+0.28078j, -0.96703-0.25467j, -0.80799-0.72661j, -0.55824-0.82968j, -0.26675-0.82934j, 0.02575-0.99967j, 0.29159-1.08881j, 0.51479-0.85731j, 0.68881-0.59433j, 0.81503-0.57942j, 0.90009-0.56507j, 0.95264-0.30411j, 0.98144-0.06326j, 0.99470-0.10282j, 0.99925-0.16678j, 1.00000-0.00000j, 0.99991+0.14087j)
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0_1_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1_0_1
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: 2*N_Zc
    type: complex
  states: {}
- name: blocks_nlog10_ff_0_1_1_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '20'
  states: {}
- name: blocks_peak_detector_xb_0_1_0_0
  id: blocks_peak_detector_xb
  parameters:
    alpha: '0.001'
    look_ahead: N_Zc*Resampled_factor - 11
    threshold_factor_fall: '10'
    threshold_factor_rise: '10'
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: byte
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_size
    type: complex
  states: {}
- name: epy_block_18_0
  id: epy_block
  parameters:
    N: N_Zc
    _source_code: "\nimport numpy as np\nfrom gnuradio import gr\nimport time\nimport pmt\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self,  inter_arrival_time_mean=100.0, tau=0.01, u=1, N=7, q=0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='PacketPoissonGeneratorNoInput',   # will show up in GRC\n            in_sig = None,\n            out_sig=[np.complex64]\n        )\n        self.u = u  # Root index of the ZC sequence\n        self.N = N  # Length of the ZC sequence\n        self.q = q  # Cyclic shift index        \n        self.inter_arrival_time_mean = inter_arrival_time_mean\n        self.time_to_next_packet = self.calculate_time_to_next_packet()        \n        self.last_packet_time = time.time_ns()\n        self.tau = tau\n        self.packet_end_time = self.last_packet_time + tau * 1e9\n        self.counter=0\n        self.transmitting = False  # Current state of transmission\n        self.ZC_sequence = self.generate_zc_sequence(self.u, self.N, self.q)\n    def generate_zc_sequence(self, u, N, q):\n        \"\"\"\n        Generate a Zadoff-Chu sequence.\n        \n        Parameters:\n        u (int): Root index of the ZC sequence.\n        N (int): Length of the ZC sequence.\n        q (int): Cyclic shift index.\n        \n        Returns:\n        np.array: Generated ZC sequence.\n        \"\"\"\n        n = np.arange(N)\n        zc_seq_origin = np.exp(-1j  * np.pi * u * n * (n + 1) / (N)) \n        zc_seq_node = np.exp(-1j  * np.pi * u * n * (n + 1 +2*q) / (N))\n        #signal = np.arange(256)\n        zc_seq = np.concatenate([zc_seq_origin,zc_seq_node], axis = 0)\n\n        #zc_seq_conj = np.conj(zc_seq)\n        #zc_zeros_padding = np.zeros(73)\n        #zc_real_block = np.exp(-1j * 2 * np.pi * u * n * (n + 1 + 2*q) / (2 * N))\n        #zc_seq = np.roll(zc_seq, q)\n        #zc_seq = np.concatenate([zc_seq,zc_seq_conj])\n        #zc_seq = zc_seq_conj\n        \n #       zc_seq = np.concatenate([zc_seq,zc_seq_conj, zc_zeros_padding])\n        return zc_seq\n    def calculate_time_to_next_packet(self):\n        randNumber = np.random.random()\n        if randNumber >= 0.99:\n            randNumber = 0.99\n        return -1e9 * np.log(1 - randNumber) / self.inter_arrival_time_mean # Time in ns\n\n    def work(self, input_items, output_items):\n        timeNow = time.time_ns()\n        \n        noutput_items = len(output_items[0])  # Number of output items to produce\n        #print(noutput_items)\n        output_items[0][:] = 0\n        if self.transmitting:\n            #print(f'counter: {self.counter}')\n            if timeNow < self.packet_end_time:\n                for i in range(noutput_items):    \n                    output_items[0][i] = self.ZC_sequence[self.counter]#[self.counter]\n                    self.counter +=1\n                    if self.counter == len(self.ZC_sequence):\n                        self.counter = 0\n                \n            else:\n                if self.counter != 0:\n                    for i in range(noutput_items):    \n                        output_items[0][i] = self.ZC_sequence[self.counter]#[self.counter]\n                        self.counter +=1\n                        if self.counter == len(self.ZC_sequence):\n                            self.counter = 0\n                            break\n                else: \n                    self.transmitting = False\n                    self.time_to_next_packet = self.calculate_time_to_next_packet()\n                    self.last_packet_time = timeNow\n                #self.counter = 0\n                \n        else:\n            if timeNow - self.last_packet_time >= self.time_to_next_packet:\n                self.transmitting = True\n                self.packet_end_time = timeNow + self.tau * 1e9\n                #output_items[0][i] = self.ZC_sequence#[self.counter]\n                self.counter =0\n        \n        return len(output_items[0])\n\n\n\n"
    inter_arrival_time_mean: Lambda
    q: Node_ID
    tau: Tau
    u: '1'
  states: {}
- name: epy_block_1_1
  id: epy_block
  parameters:
    Node: Node_ID
    Nzc: N_Zc
    RF: Resampled_factor
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport pmt\nimport csv\nfrom datetime import datetime\nfrom scipy.signal import find_peaks\n\nclass blk(gr.sync_block):  \n    def __init__(self, vec_size=2048, Nzc=61, RF=4, Node=1, filename=\"/home/student/Downloads/metadata.csv\"):\n        gr.sync_block.__init__(\n            self,\n            name='NodeIdentifier',  \n            in_sig=[(np.uint8, vec_size), (np.complex64, vec_size)],\n            out_sig=None\n        )\n        self.vec_size = vec_size  \n        self.Nzc = Nzc\n        self.RF = RF\n        self.Sender_ID = Node\n        self.packet_started = [False for _ in range(7)]\n        self.filename = filename\n\n        # Initialize CSV file\n        try:\n            with open(self.filename, 'a', newline='') as f:\n                writer = csv.writer(f)\n                if f.tell() == 0:\n                    writer.writerow([\"Sender_ID\", \"Receiver_ID\", \"Timestamp\", \"Received Power (dBm)\"])\n        except IOError:\n            print(f\"Error: Could not write to file {self.filename}\")\n\n    def calculate_rsrp(self, signal,non_zero_indices):\n        signal = signal.flatten()\n        len_sig = len(non_zero_indices)\n        \n        magnitude_squared = np.abs(signal[non_zero_indices[0]:non_zero_indices[0]+len_sig*self.RF*self.Nzc])**2\n        \n        rsrp_linear = np.mean(magnitude_squared) #Results may be smaller that actual RSRP, since some part of signal may not have any zc sequence but only noise\n        rsrp_dbm = 10 * np.log10(rsrp_linear) if rsrp_linear > 0 else -np.inf\n        return rsrp_dbm\n\n    def get_current_timestamp(self):\n        return datetime.now().strftime('%Y-%m-%d %H:%M:%S.%f')[:-3]\n\n    def start_packet(self, Receiver_ID, signal,non_zero_indices):\n        Receiver_ID += 1  \n        start_time = self.get_current_timestamp()\n        rsrp_dbm = self.calculate_rsrp(signal,non_zero_indices)\n        try:\n            with open(self.filename, 'a', newline='') as f:\n                writer = csv.writer(f)\n                writer.writerow([self.Sender_ID, Receiver_ID, start_time, f\"{rsrp_dbm:.6f}\"])\n        except IOError:\n            print(f\"Error: Could not write to file {self.filename}\")\n\n\n    def work(self, input_items, output_items):\n        in0 = input_items[0]  \n        in1 = input_items[1]  \n\n        non_zero_indices = np.nonzero(in0)[1]\n        packet_detector = [False for _ in range(7)]\n\n        if len(non_zero_indices) != 0:\n            for i in range(len(non_zero_indices) - 1):\n                if non_zero_indices[i + 1] > non_zero_indices[i]:\n                    node_index = ((np.abs(non_zero_indices[i + 1] - non_zero_indices[i] - self.Nzc * self.RF) - self.RF) // self.RF) % 7\n                    packet_detector[node_index] = True\n\n            if sum(packet_detector) == 1:\n                for i in range(len(packet_detector)):\n                    if packet_detector[i] and not self.packet_started[i]:\n                    \n                        self.packet_started[i] = True\n                        self.start_packet(i, in1,non_zero_indices)\n            else:\n                for i in range(len(self.packet_started)):\n                    if self.packet_started[i]:\n                        self.packet_started[i] = False\n                return 1  \n\n        for i in range(len(self.packet_started)):\n            if self.packet_started[i] and len(non_zero_indices) == 0:\n                self.packet_started[i] = False\n\n        return len(in1)\n\n"
    filename: f'./Results/Measurements_Node_{Node_ID}.csv'
    vec_size: vector_size
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: numpy.conj(zc_seq0_resampled_2times)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_1
  id: import
  parameters:
    imports: import pmt
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_1_1_2_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Nodes
    marker1: '0'
    name: '"ReceivedSIgnal"'
    size: 25000*50
    srate: samp_rate*Resampled_factor
    type: float
    update_time: '2'
    ylabel: '"Magnitude"'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0_2_1_1_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Nodes
    marker1: '0'
    name: '"Peak"'
    size: 25000*50
    srate: samp_rate*Resampled_factor
    type: float
    update_time: '2'
    ylabel: '"Magnitude"'
    ymin: '0'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: samp_rate
    center_freq0: center_freq_mhz*1e6
    dev_args: '""'
    gain0: tx_gain
    gain_type0: normalized
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq_mhz*1e6
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate*Resampled_factor
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_2_1_1_2_0_0_0, '0']
- [blocks_complex_to_mag_0_1_0, '0', blocks_peak_detector_xb_0_1_0_0, '0']
- [blocks_complex_to_mag_0_1_0_1, '0', blocks_nlog10_ff_0_1_1_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_nlog10_ff_0_1_1_0, '0', qtgui_time_sink_x_0_2_1_1_2_0_0, '0']
- [blocks_peak_detector_xb_0_1_0_0, '0', blocks_char_to_float_0, '0']
- [blocks_peak_detector_xb_0_1_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', epy_block_1_1, '0']
- [blocks_stream_to_vector_0_0_0, '0', epy_block_1_1, '1']
- [epy_block_18_0, '0', uhd_usrp_sink_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_complex_to_mag_0_1_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_0_1_0_1, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']
- [uhd_usrp_source_0, '0', fft_filter_xxx_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
